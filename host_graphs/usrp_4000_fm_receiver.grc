options:
  parameters:
    generate_options: qt_gui
    id: usrp_4000_fm_receiver
    output_language: python
    title: usrp_4000_fm_receiver
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 90.0e6
    step: 1e4
    stop: 110e6
    value: 102.6e6
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '5'
  states: {}
- name: low_pass_cutoff
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '5000'
    step: '1000'
    stop: '30000'
    value: '30000'
  states: {}
- name: low_pass_transition
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '500'
    step: '100'
    stop: '5000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: 2e5
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: |-
      This can be an simple indicator 
      for measuring the signal quality.
      If the MA rises, the proportion of 
      good signal bins increases.
      For good signal quality, this value has 
      to be maximized.
    length: '1000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: 127.0.0.1
    noblock: 'True'
    port: '10000'
    type: float
    vlen: '1'
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      This block outputs 1 for a sufficient 
      signal and 0 for a noisy signal.
    high: '1'
    init: '0'
    low: '0.5'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: low_pass_cutoff
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: low_pass_transition
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: source_view
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: center_freq
    fftsize: '1024'
    name: after_low_pass
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: center_freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    fbw: '0.1'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:9999
    timeout: '100'
    type: float
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:9998
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_max_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_max_xx_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_threshold_ff_0, '0', zeromq_pub_sink_0_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_tcp_server_sink_0, '0']
- [rational_resampler_xxx_0, '0', zeromq_pub_sink_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
