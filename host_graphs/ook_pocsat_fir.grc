options:
  parameters:
    generate_options: qt_gui
    id: ook_pocsat_fir
    output_language: python
    title: ook_pocsat_fir
  states: {}

blocks:
- name: choose_freq
  id: variable_qtgui_chooser
  parameters:
    label0: 466.23e6
    label1: 465.97e6
    label2: 466.07e6
    num_opts: '5'
    option0: 466.23e6
    option1: 465.97e6
    option2: 466.07e6-7e4
    option3: '3'
    option4: '4'
    type: real
    value: 466.07e6-7e4
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '20'
  states: {}
- name: freq_adjust
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-1000e3'
    step: 1e3
    stop: 1000e3
    value: '-229.3e3'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 2.5e3
  states: {}
- name: lowpass_cutoff
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 5e3
    step: '1000'
    stop: 50e3
    value: 10e3
  states: {}
- name: lowpass_transition
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1000'
    step: '1000'
    stop: 30e3
    value: 1e3
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-5'
    step: '0.1'
    stop: '5'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sqelch
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-70'
    step: '1'
    stop: '-50'
    value: '-65'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(samp_rate)
    max_dev: fsk_deviation_hz
    quad_rate: int(samp_rate)
    tau: '75e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate/(decimation))/(2*math.pi*fsk_deviation_hz/8.0)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_adjust
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sqelch
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: '100'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1472'
    type: byte
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    comment: outputs [0,1] bits
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '15000'
    psize: '1472'
    type: byte
    vlen: '1472'
  states: {}
- name: blocks_udp_sink_1
  id: blocks_udp_sink
  parameters:
    comment: |-
      try to feed stream into
       multimon-ng like gqrx does
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '14000'
    psize: '1'
    type: int
    vlen: '1'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.1'
    gain_omega: '0.01'
    mu: '0'
    omega: samp_rate/(decimation*symbol_rate)*(1+0.0)
    omega_relative_limit: '0.01'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: choose_freq
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(5, samp_rate, samp_rate/(10*decimation), 1000)
    type: ccc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    bw0: samp_rate
    dc_offset_mode0: '2'
    freq0: choose_freq
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: choose_freq
    fftsize: '1024'
    name: after_lowpass
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: choose_freq
    fftsize: '1024'
    name: after_nbfm
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    comment: show binary bit detection
    size: '1024'
    srate: samp_rate/decimation
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: choose_freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(2000)
    fbw: '0.4'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: choose_freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '50'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', rational_resampler_xxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_float_to_int_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_float_to_int_0, '0', blocks_udp_sink_1, '0']
- [blocks_multiply_xx_0, '0', analog_nbfm_rx_0, '0']
- [blocks_multiply_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_udp_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_stream_to_vector_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_add_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
