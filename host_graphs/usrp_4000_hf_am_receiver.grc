options:
  parameters:
    generate_options: qt_gui
    id: usrp_4000_hf_am_receiver
    output_language: python
    title: usrp_4000_hf_am_receiver
  states: {}

blocks:
- name: band_pass_high_cutoff
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1000'
    step: '100'
    stop: '10000'
    value: '6000'
  states: {}
- name: band_pass_low_cutoff
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '100'
    step: '100'
    stop: '10000'
    value: '500'
  states: {}
- name: band_pass_transition
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '100'
    step: '100'
    stop: '4000'
    value: '400'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 1.0e6
    step: 1e4
    stop: 10e6
    value: 1.0e6
  states: {}
- name: decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: band_pass_high_cutoff
    low_cutoff_freq: band_pass_low_cutoff
    samp_rate: samp_rate
    type: fir_filter_fff
    width: band_pass_transition
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: |-
      This can be an simple indicator 
      for measuring the signal quality.
      If the MA rises, the proportion of 
      good signal bins increases.
      For good signal quality, this value has 
      to be maximized.
    length: '1000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      This block outputs 1 for a sufficient 
      signal and 0 for a noisy signal.
    high: '1'
    init: '0'
    low: '0.5'
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center_freq
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,samp_rate/(2*decim), 2000)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: signal_source_freq
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: AM signal
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: signal_source_time
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:9998
    timeout: '100'
    type: float
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', blocks_complex_to_mag_0_0, '0']
- [band_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_0_0, '0', band_pass_filter_0, '0']
- [blocks_max_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_max_xx_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_threshold_ff_0, '0', zeromq_pub_sink_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_1, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
