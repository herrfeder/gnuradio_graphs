options:
  parameters:
    generate_options: qt_gui
    id: ook_pocsat_from_file
    output_language: python
    title: ook_pocsat_from_file
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: freq_adjust
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-1000e3'
    step: 1e3
    stop: 1000e3
    value: '-160e3'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 4.5e3
  states: {}
- name: lowpass_cutoff
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 5e3
    step: '1000'
    stop: 50e3
    value: 10e3
  states: {}
- name: lowpass_transition
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1000'
    step: '1000'
    stop: 30e3
    value: 1e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sqelch
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-70'
    step: '1'
    stop: '-50'
    value: '-63'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /root/test_ook_output
    repeat: 'False'
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1472'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    comment: outputs [0,1] bits
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '15000'
    psize: '1472'
    type: byte
    vlen: '1472'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.1'
    gain_omega: '0.01'
    mu: '0'
    omega: samp_rate/(decimation*symbol_rate)*(1+0.0)
    omega_relative_limit: '0.01'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate, fsk_deviation_hz, fsk_deviation_hz*decimation)
    type: fcc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 466.07e6
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    comment: show binary bit detection
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_mag_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_udp_sink_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_stream_to_vector_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
