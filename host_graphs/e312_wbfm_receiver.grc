options:
  parameters:
    generate_options: qt_gui
    id: e312_wbfm_receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 90e6
    step: 1e5
    stop: 110e6
    value: 98.5e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '5'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: '"192.168.10.2"'
    callback: center_freq
    port: '30000'
    variable: center_freq
  states: {}
- name: xmlrpc_client_0_0
  id: xmlrpc_client
  parameters:
    addr: '"192.168.10.2"'
    callback: rf_gain
    port: '30000'
    variable: rf_gain
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://192.168.10.2:9999
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_pull_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
