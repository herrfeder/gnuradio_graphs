options:
  parameters:
    generate_options: qt_gui
    id: zmq_sine_test
    output_language: python
    title: zmq_sine_test
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.5'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '500'
    step: '10'
    stop: '2000'
    value: '1000'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-10'
    step: '1'
    stop: '10'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: '"192.168.10.2"'
    callback: amplitude
    port: '30000'
    variable: amplitude
  states: {}
- name: xmlrpc_client_0_0
  id: xmlrpc_client
  parameters:
    addr: '"192.168.10.2"'
    callback: frequency
    port: '30000'
    variable: frequency
  states: {}
- name: xmlrpc_client_0_0_0
  id: xmlrpc_client
  parameters:
    addr: '"192.168.10.2"'
    callback: offset
    port: '30000'
    variable: offset
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://192.168.10.2:9231
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [zeromq_pull_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
