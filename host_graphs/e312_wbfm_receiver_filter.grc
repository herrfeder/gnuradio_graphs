options:
  parameters:
    generate_options: qt_gui
    id: e312_wbfm_receiver_filter
    output_language: python
    title: e312_wbfm_receiver_filter
  states: {}

blocks:
- name: bandpass_high_cutoff
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '5000'
    step: 0.1e3
    stop: '10000'
    value: '6000'
  states: {}
- name: bandpass_low_cutoff
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '100'
    step: 0.1e3
    stop: '6000'
    value: '600'
  states: {}
- name: bandpass_transition
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '100'
    step: 0.1e3
    stop: '1000'
    value: '400'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 90e6
    step: 1e5
    stop: 110e6
    value: 98.5e6
  states: {}
- name: e312sdr
  id: variable
  parameters:
    value: '"192.168.10.2"'
  states: {}
- name: lowpass_cutoff
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 0.5e5
    step: 0.1e5
    stop: 1.5e5
    value: 1e5
  states: {}
- name: lowpass_transition
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 0.5e4
    step: 0.1e4
    stop: 1.5e4
    value: 1e4
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '5'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: set_center_freq
  id: variable
  parameters:
    value: '"set_center_freq"'
  states: {}
- name: set_lowpass_cutoff
  id: variable
  parameters:
    value: '"set_lowpass_cutoff"'
  states: {}
- name: set_lowpass_transition
  id: variable
  parameters:
    value: '"set_lowpass_transition"'
  states: {}
- name: set_rf_gain
  id: variable
  parameters:
    value: '"set_rf_gain"'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: '"plughw:0,0"'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: bandpass_high_cutoff
    low_cutoff_freq: bandpass_low_cutoff
    samp_rate: samp_rate
    type: fir_filter_fff
    width: bandpass_transition
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*100
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: e312sdr
    callback: set_center_freq
    port: '30000'
    variable: center_freq
  states: {}
- name: xmlrpc_client_0_0
  id: xmlrpc_client
  parameters:
    addr: e312sdr
    callback: set_rf_gain
    port: '30000'
    variable: rf_gain
  states: {}
- name: xmlrpc_client_0_0_0
  id: xmlrpc_client
  parameters:
    addr: e312sdr
    callback: set_lowpass_transition
    port: '30000'
    variable: lowpass_transition
  states: {}
- name: xmlrpc_client_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: e312sdr
    callback: set_lowpass_cutoff
    port: '30000'
    variable: lowpass_cutoff
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://192.168.10.2:9999
    timeout: '100'
    type: float
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://192.168.10.2:9999
    timeout: '100'
    type: float
  states: {}

connections:
- [band_pass_filter_0, '0', audio_sink_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_pull_source_0, '0', band_pass_filter_0, '0']
- [zeromq_sub_source_0, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
